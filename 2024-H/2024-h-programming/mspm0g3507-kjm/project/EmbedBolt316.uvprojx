# Keil uVision project EmbedBolt316.uvprojx, settings and files
target EmbedBolt316 (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: EmbedBolt316 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\project;..\source;..\source\third_party\CMSIS\Core\Include;..\kernel\freertos\Source\include;..\kernel\freertos\Source\portable\GCC\ARM_CM0;..\kernel\freertos\builds\LP_MSPM0G3507\release;..\custom\app\ui;..\custom\app\communication;..\custom\app\controller;..\custom\hardware\drivers;..\custom\hardware\bsp;..\custom\include;..\custom\user;..\custom\utils;..\source\third_party\u8g2;..\custom\tests;..\custom\app\imu\wit_gyro;..\custom\app\imu\mpu6050_dmplib
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group include
    ../custom/include/: common_defines.h common_include.h log_config.h
  group user
    ../custom/user/: main.c periodic_event_task.c mspm0g3507_it.c
  group tests
    ../custom/tests/: gray_detection_test.c wit_jyxx_test.c motor_test.c mpu6050_dmp_test.c bluetooth_test.c
  group project
    ./: ti_msp_dl_config.c startup_mspm0g350x_uvision.s EmbedBolt316.syscfg
  group app/communication
    ../custom/app/communication/: serialplot_protocol.c lwrb.c lwpkt.c bluetooth.c
  group app/controller
    ../custom/app/controller/: encoder_app.c gray_detection_app.c motor_app.c alert.c car_controller.c car_state_machine.c car_debug.c car_pid.c pid.c
  group app/ui
    ../custom/app/ui/: multi_button.c oled_driver.c ui_animation.c ui_app.c ui_button.c ui_drawing.c ui_logic.c
  group app/imu/dmplib
    ../custom/app/imu/mpu6050_dmplib/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpuiic.c
  group app/imu/wit_gyro
    ../custom/app/imu/wit_gyro/: wit_jyxx.c
  group utils
    ../custom/utils/: delay.c log.c systick.c
  group hardware/drivers
    ../custom/hardware/drivers/: encoder.c motor_l298n.c motor_tb6612.c pca9555.c beep.c rgb_led.c _74hc595.c
  group hardware/bsp
    ../custom/hardware/bsp/: sw_i2c.c uart_driver.c bsp_spi.c
  group third_party/u8g2
    ../source/third_party/u8g2/csrc/: u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_hvline.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_polygon.c u8g2_setup.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_d_ssd1306_128x64_noname.c u8x8_display.c u8x8_gpio.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c u8x8_capture.c u8g2_fonts.c
