# Keil uVision project EmbedBolt316.uvprojx, settings and files
target EmbedBolt316 (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: EmbedBolt316 +hex
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\core\task_2022c;..\Keil;..\..\..\..\platforms\ti-mspm0g3507\source;..\..\..\..\platforms\ti-mspm0g3507\tests\unit_tests;..\..\..\..\platforms\ti-mspm0g3507\source\third_party\u8g2;..\..\..\..\platforms\ti-mspm0g3507\source\third_party\CMSIS\Core\Include;..\..\..\..\platforms\ti-mspm0g3507\custom_src\application\control;..\..\..\..\platforms\ti-mspm0g3507\custom_src\core\system;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\actuators\motor;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\actuators\voice_light_alert;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\communication;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\display\oled;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\io_expander;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\sensors\encoder;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\sensors\gray_detect;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\sensors\mpu6050;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\sensors\vl53l1x;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\sensors\vl53l1x\vl53l1x_platform;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\sensors\wit_gyro;..\..\..\..\platforms\ti-mspm0g3507\custom_src\hal\i2c;..\..\..\..\platforms\ti-mspm0g3507\custom_src\hal\spi;..\..\..\..\platforms\ti-mspm0g3507\custom_src\hal\uart;..\..\..\..\platforms\ti-mspm0g3507\custom_src\hal\adc;..\..\..\..\platforms\ti-mspm0g3507\custom_src\middleware\communication\lwpkt;..\..\..\..\platforms\ti-mspm0g3507\custom_src\middleware\communication\lwrb;..\..\..\..\platforms\ti-mspm0g3507\custom_src\middleware\communication\protocol;..\..\..\..\platforms\ti-mspm0g3507\custom_src\middleware\ui\button;..\..\..\..\platforms\ti-mspm0g3507\custom_src\middleware\ui\graphics;..\..\..\..\platforms\ti-mspm0g3507\custom_src\utils;..\..\..\..\platforms\ti-mspm0g3507\custom_src\middleware\ui;..\..\..\..\platforms\ti-mspm0g3507\custom_src\drivers\sensors\imu660ra;..\..\..\..\platforms\ti-mspm0g3507\custom_src\middleware\fusion;..\..\..\..\platforms\ti-mspm0g3507\custom_src\core\config
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ../../../../platforms/ti-mspm0g3507/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Config
    ../../../../platforms/ti-mspm0g3507/custom_src/core/config/: common_include.h log_config.h
  group Application/Tasks
    ../core/task_2022c/: task22c_config.h task22c_bluetooth_app.c task22c_car_controller.c task22c_car_pid_parameter.c task22c_mission_table.c task22c_ui_app.c
  group Core
    ../../../../platforms/ti-mspm0g3507/custom_src/core/system/: mspm0g3507_it.c periodic_event_task.c systick.c
    ./: EmbedBolt316.syscfg ti_msp_dl_config.c
    ../core/: main.c
  group HAL
    ../../../../platforms/ti-mspm0g3507/custom_src/hal/adc/: hal_adc.c
    ../../../../platforms/ti-mspm0g3507/custom_src/hal/i2c/: hal_soft_i2c.c
    ../../../../platforms/ti-mspm0g3507/custom_src/hal/spi/: hal_spi.c
    ../../../../platforms/ti-mspm0g3507/custom_src/hal/uart/: hal_uart.c
  group Drivers/Sensors
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/sensors/encoder/: encoder.c encoder_user.c
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/sensors/gray_detect/: ganv_calibration.c gray_detection.c no_mcu_ganv.c
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/sensors/imu660ra/: attitude_algorithm.c pose.c pose_math.c zf_device_imu_interface.c zf_device_imu660ra.c
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/sensors/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpuiic.c
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/sensors/vl53l1x/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/sensors/vl53l1x/vl53l1x_platform/: vl53l1_platform.c vl53l1_read.c
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/sensors/wit_gyro/: wit_jyxx.c
  group Drivers/Actuators
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/actuators/motor/: motor_l298n.c motor_tb6612.c motor_user.c
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/actuators/voice_light_alert/: beep.c rgb_led.c voice_light_alert.c
  group Drivers/Communication
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/communication/: bluetooth.c maix_cam.c
  group Drivers/Display
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/display/oled/: oled_driver.c
  group Drivers/IO_Expander
    ../../../../platforms/ti-mspm0g3507/custom_src/drivers/io_expander/: _74hc595.c pca9555.c
  group Middleware/Communication
    ../../../../platforms/ti-mspm0g3507/custom_src/middleware/communication/lwpkt/: lwpkt.c
    ../../../../platforms/ti-mspm0g3507/custom_src/middleware/communication/lwrb/: lwrb.c
    ../../../../platforms/ti-mspm0g3507/custom_src/middleware/communication/protocol/: cam_protocol.c serialplot_protocol.c
  group Middleware/UI
    ../../../../platforms/ti-mspm0g3507/custom_src/middleware/ui/button/: multi_button.c ui_button.c
    ../../../../platforms/ti-mspm0g3507/custom_src/middleware/ui/graphics/: ui_animation.c ui_drawing.c ui_logic.c
  group Middleware/Fusion
    ../../../../platforms/ti-mspm0g3507/custom_src/middleware/fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
  group Application/Control
    ../../../../platforms/ti-mspm0g3507/custom_src/application/control/: car_debug.c car_state_machine.c pid.c
  group Utils
    ../../../../platforms/ti-mspm0g3507/custom_src/utils/: delay.c log.c
  group Third_Party/U8G2
    ../../../../platforms/ti-mspm0g3507/source/third_party/u8g2/csrc/: u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_polygon.c u8g2_setup.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_display.c u8x8_gpio.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Tests/UnitTests
    ../../../../platforms/ti-mspm0g3507/tests/unit_tests/: bluetooth_test.c gray_detection_test.c maix_test.c motor_test.c mpu6050_dmp_test.c no_mcu_ganv_test.c vl53l1_test.c wit_jyxx_test.c
  group Startup
    ../../../../platforms/ti-mspm0g3507/project/startup/: startup_mspm0g350x_uvision.s
